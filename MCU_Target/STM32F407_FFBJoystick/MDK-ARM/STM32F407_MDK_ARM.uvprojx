# Keil uVision project STM32F407_MDK_ARM.uvprojx, settings and files
target STM32F407_MDK_ARM (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: STM32F407_MDK_ARM +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --cpp11
  c include: ../Core/Inc;../USB;../../../FFBJoystick\Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x800c000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c spi.c tim.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group FFBJoystick
    ../../../FFBJoystick/Src/: ACServo.cpp cppmain.cpp crc16.c DAC856x.c FFB_Calculator.cpp FFBConfig.cpp FFBMain.cpp filters.cpp Joystick.cpp MotorDriver.cpp MotorPWM.cpp PID_v2.cpp PIDReportHandler.cpp QEncoder.cpp stm32_Flash.c USB_Handler.cpp
    ../../../FFBJoystick/Inc/: ACServo.h cppmain.h crc16.h DAC856x.h FFB_Calculator.h FFBConfig.h FFBConfig_DataType.h FFBDescriptor.h FFBMain.h filters.h filters_defs.h Joystick.h MotorDriver.h MotorPWM.h PID_v2.h PIDReportHandler.h PIDReportType.h QEncoder.h stm32_Flash.h types.h USB_Handler.h
  group USB
    ../USB/: usb_device.c usb_device.h usbd_conf.c usbd_conf.h usbd_core.c usbd_core.h usbd_ctlreq.c usbd_ctlreq.h usbd_def.h usbd_desc.c usbd_desc.h usbd_ioreq.c usbd_ioreq.h usbd_joystick_hid_if.c usbd_joystick_hid_if.h usbd_joystickhid.c usbd_joystickhid.h
software components: CMSIS:CORE 4.3.0
